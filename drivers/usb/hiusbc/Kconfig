## drivers/usb/hiusbc/Kconfig
```kconfig
config USB_HIUSBC
	tristate "Self-developed USB Controller Driver"
	help
	  Say Y to enable Self-developed USB Controller Driver
```
